<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DFT_prova\DFT_prova.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Terminal1\Terminal1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Terminal2\Terminal2.ewp</path>
    </project>
    <batchBuild />
</workspace>

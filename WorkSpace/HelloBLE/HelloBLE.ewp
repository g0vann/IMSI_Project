# IAR project HelloBLE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: HelloBLE.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group AD5940lib
    ../AD5940lib/: ad5940.c ad5940.h
    ./: ADICUP3029Port.c
  group Application
    ./: hello_world.c hello_world.h
  group Inizialize
    ./: adi_initialize.c adi_initialize.h pinmux.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/BLE Bluetooth low energy
    RTE/BLE/: adi_ble_config.h
    ${CMSIS_PACK_PATH_AnalogDevices#ADI-BleSoftware#1.0.1}$/Source/communication/ble/radio/: adi_ble_logevent.c adi_ble_radio.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADI-BleSoftware#1.0.1}$/Source/communication/ble/framework/noos/: adi_ble_noos.c
    ${CMSIS_PACK_PATH_AnalogDevices#ADI-BleSoftware#1.0.1}$/Source/communication/ble/transport/: adi_ble_transport.c
  group CMSIS-Pack/Device Examples Support
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/: common.c
  group CMSIS-Pack/Device Global Configuration
    RTE/Device/ADuCM3029/: adi_cycle_counting_config.h adi_global_config.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM3029/: startup_ADuCM3029.s system_ADuCM3029.c
  group CMSIS-Pack/Device.Drivers DMA
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/dma/: adi_dma.c
  group CMSIS-Pack/Device.Drivers GPIO
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/gpio/: adi_gpio.c
  group CMSIS-Pack/Device.Drivers Power
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/pwr/: adi_pwr.c
    RTE/Device/ADuCM3029/: adi_pwr_config.h
  group CMSIS-Pack/Device.Drivers SPI
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/spi/: adi_spi.c
    RTE/Device/ADuCM3029/: adi_spi_config.h
  group CMSIS-Pack/Device.Drivers TMR
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/tmr/: adi_tmr.c
    RTE/Device/ADuCM3029/: adi_tmr_config.h
  group CMSIS-Pack/Device.Drivers UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/uart/: adi_uart.c
    RTE/Device/ADuCM3029/: adi_uart_config.h
  group CMSIS-Pack/Device.Drivers WDT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/wdt/: adi_wdt.c
    RTE/Device/ADuCM3029/: adi_wdt_config.h

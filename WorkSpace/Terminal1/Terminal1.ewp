# IAR project Terminal1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: Terminal1.srec
  ILINK.IlinkOutputFile: Terminal1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group AD5940lib
    ../AD5940lib/: ad5940.c ad5940.h
    ./: ADICUP3029Port.c
  group Application
    ./: ADuCM3029_demo_cli.c ADuCM3029_demo_cli.h Cli.c Cli.h Communication.c Communication.h Timer.c Timer.h
  group Inizialize
    ./: adi_initialize.c adi_initialize.h pinmux_config.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Cycle Count
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/: adi_cyclecount.c
  group CMSIS-Pack/Device Global Configuration
    RTE/Device/ADuCM3029/: adi_cycle_counting_config.h adi_global_config.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM3029/: startup_ADuCM3029.s system_ADuCM3029.c
  group CMSIS-Pack/Device.Drivers DMA
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/dma/: adi_dma.c
  group CMSIS-Pack/Device.Drivers Power
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/pwr/: adi_pwr.c
    RTE/Device/ADuCM3029/: adi_pwr_config.h
  group CMSIS-Pack/Device.Drivers UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/uart/: adi_uart.c
    RTE/Device/ADuCM3029/: adi_uart_config.h
  group CMSIS-Pack/Device.Drivers WDT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/wdt/: adi_wdt.c
    RTE/Device/ADuCM3029/: adi_wdt_config.h

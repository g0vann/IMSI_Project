<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AD5940_SPI\ADICUP3029\AD5940_SPI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\First\First.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>AD5940_ADC</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_Temperature</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_Amperometric</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_BATImpedance</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_BIA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_BioElec</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_BIOZ-2Wire</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_ChronoAmperometric</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_DFT</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_ECG</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_ECSensEIS</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_EDA</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_HSDACCal</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_Impedance</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_LPDAC</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_LPLoop</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_Ramp</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_Reset</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_Sequencer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_SPI</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_SqrWaveVoltmmetry</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>AD5940_WG</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>

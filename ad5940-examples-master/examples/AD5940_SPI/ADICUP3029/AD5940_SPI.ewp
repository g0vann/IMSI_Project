# IAR project AD5940_SPI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_594X; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ; ..\..\ad5940lib; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: AD5940_SPI.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group AD5940Lib
    ../../ad5940lib/: ad5940.c
    ./: ADICUP3029Port.c
  group application
    ../: AD5940_SPI.c
    ./: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Cycle Count
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/: adi_cyclecount.c
  group CMSIS-Pack/Device.Drivers DMA
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/dma/: adi_dma.c
  group CMSIS-Pack/Device.Drivers Power
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/pwr/: adi_pwr.c
    RTE/Device/ADuCM3029/: adi_pwr_config.h
  group CMSIS-Pack/Device.Drivers SPI
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/spi/: adi_spi.c
    RTE/Device/ADuCM3029/: adi_spi_config.h
  group CMSIS-Pack/Device.Drivers UART
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/uart/: adi_uart.c
    RTE/Device/ADuCM3029/: adi_uart_config.h
  group CMSIS-Pack/Device.Drivers WDT
    ${CMSIS_PACK_PATH_AnalogDevices#ADuCM302x_DFP#3.2.0}$/Source/drivers/wdt/: adi_wdt.c
    RTE/Device/ADuCM3029/: adi_wdt_config.h
  group CMSIS-Pack/Device Global Configuration
    RTE/Device/ADuCM3029/: adi_cycle_counting_config.h adi_global_config.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ADuCM3029/: startup_ADuCM3029.s system_ADuCM3029.c
